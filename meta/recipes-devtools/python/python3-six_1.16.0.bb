inherit setuptools3
require python-six.inc

SRC_URI[md5sum] = "a7c927740e4964dd29b72cebfc1429bb"
SRC_URI[sha256sum] = "1e61c37477a1626458e36f7b1d82aa5c9b094fa4802892072e49de9c60c4c926"
